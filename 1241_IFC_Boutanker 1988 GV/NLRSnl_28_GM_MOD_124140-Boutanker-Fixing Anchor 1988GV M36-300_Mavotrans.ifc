Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:42:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:42:52 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{18FE4D3B-A3FB-4AD0-BB1A-DB9C1BDA7DC9}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:42:52 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:42:52 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:42:52 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1241_Boutanker 1988 GV; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1241_Boutanker 1988 GV; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcBuildingElementProxy: 124140, NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19:124140_M36-300mm:321957
In: Level 0
Type - Description: Boutanker | Fixing Anchor 1988 GV M36 x 300mm; Classification: 28.20 (Default Classification); Material: kunststof (2), elektrolytisch verzinkt, onbehandeld kwaliteit 8.8 (2)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a (mm): 76 mm; d_nom: M36; I (mm): 110 mm; L (mm): 300 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 124140; Beschrijving | Description: Boutanker | Fixing Anchor 1988 GV M36 x 300mm; Certificaten | Certification: CE + ETA-13/0401; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Opmerkingen | Comments: Rekenprogramma's om de toelaatbare belastingen op de bevestigingsankers te berekenen, is te downloaden op onze website. | Calculation program to calculate the permissible load on the fastening anchors can be downloaded from our webpage.; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 124140_M36-300mm; URL: https://mavotrans.nl/boutanker-1988-gv.html; Verpakkingshoeveelheid | Sales packaging: Verpakt per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Draadbus is gegalvaniseerd en de bout is onbehandeld, kwaliteit 8.8 | Socket is galvanized and bolt is untreated 8.8
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19; head height: 19 mm; height plastic: 5 mm; length "a": 76 mm; length "l": 110 mm; radius "d-nom": 18 mm; radius plastic 1: 24 mm; radius plastic 2: 21.5 mm; radius thread: 20 mm; radius wrench size: 25 mm; size bolt "d-nom": 36 mm; thickness plastic ring: 1.5 mm; wrench size: 50 mm
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19:124140_M36-300mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 206.5 mm; Depth: 206.5 mm
Constraints - Level: Level: Level 0; Offset: 100 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0314837 m2; Volume: 0.000279387 m3
Other - Family: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124140_M36-300mm; Family and Type: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124140_M36-300mm; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124140_M36-300mm; Type Id: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124140_M36-300mm
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
