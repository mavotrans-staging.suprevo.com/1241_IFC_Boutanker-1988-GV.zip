Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:42:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:42:49 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{1AB90A36-FF49-402D-A568-F427EC41CE0E}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:42:49 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:42:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:42:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1241_Boutanker 1988 GV; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1241_Boutanker 1988 GV; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcBuildingElementProxy: 124127, NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19:124127_M20-270mm:321745
In: Level 0
Type - Description: Boutanker | Fixing Anchor 1988 GV M20 x 270mm; Classification: 28.20 (Default Classification); Material: kunststof (2), elektrolytisch verzinkt, onbehandeld kwaliteit 8.8 (2)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a (mm): 37 mm; d_nom: M20; I (mm): 55 mm; L (mm): 270 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 124127; Beschrijving | Description: Boutanker | Fixing Anchor 1988 GV M20 x 270mm; Certificaten | Certification: CE + ETA-13/0401; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Opmerkingen | Comments: Rekenprogramma's om de toelaatbare belastingen op de bevestigingsankers te berekenen, is te downloaden op onze website. | Calculation program to calculate the permissible load on the fastening anchors can be downloaded from our webpage.; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 124127_M20-270mm; URL: https://mavotrans.nl/boutanker-1988-gv.html; Verpakkingshoeveelheid | Sales packaging: Verpakt per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Draadbus is gegalvaniseerd en de bout is onbehandeld, kwaliteit 8.8 | Socket is galvanized and bolt is untreated 8.8
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19; head height: 13 mm; height plastic: 5 mm; length "a": 37 mm; length "l": 55 mm; radius "d-nom": 10 mm; radius plastic 1: 16 mm; radius plastic 2: 13.5 mm; radius thread: 12 mm; radius wrench size: 16 mm; size bolt "d-nom": 20 mm; thickness plastic ring: 1.5 mm; wrench size: 32 mm
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19:124127_M20-270mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 221.5 mm; Depth: 221.5 mm
Constraints - Level: Level: Level 0; Offset: 100 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0138241 m2; Volume: 0.0000898424 m3
Other - Family: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124127_M20-270mm; Family and Type: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124127_M20-270mm; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124127_M20-270mm; Type Id: NLRSnl_28_GM_MOD_1241-Boutanker-Fixing Anchor 1988GV_Mavotrans_R19: 124127_M20-270mm
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
